# Copyright (C) 2012 Khem Raj <khem@openembedded.org>
# Released under the MIT license (see COPYING.MIT for the terms)

require gcc-linaro-common-4.6.inc
require recipes-devtools/gcc/gcc-cross-canadian_${BASEPV}.bb
