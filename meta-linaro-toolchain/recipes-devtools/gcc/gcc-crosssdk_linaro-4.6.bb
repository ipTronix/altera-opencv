require gcc-linaro-common-4.6.inc
require recipes-devtools/gcc/gcc-crosssdk_${BASEPV}.bb
