require gcc-linaro-common-4.6.inc
require recipes-devtools/gcc/libgcc_${BASEPV}.bb
