require gcc-linaro-common-4.6.inc
require recipes-devtools/gcc/gcc-cross-initial_${BASEPV}.bb
