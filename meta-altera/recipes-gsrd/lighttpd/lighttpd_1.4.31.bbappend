RDEPENDS_${PN} += " lighttpd-module-cgi "
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
