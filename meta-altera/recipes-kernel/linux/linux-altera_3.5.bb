require recipes-kernel/linux/linux-altera.inc

