require recipes-kernel/linux-libc-headers/linux-libc-headers.inc
