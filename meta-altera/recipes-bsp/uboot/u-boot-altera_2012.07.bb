require u-boot-altera.inc
