require u-boot-mkimage-altera.inc
