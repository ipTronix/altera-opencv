UBOOT_VERSION = "2012.04"

UBOOT_MACHINE = "vtdev5xs1_config"
LIC_FILES_CHKSUM = "file://${S}/COPYING;startline=26;md5=1707d6db1d42237583f50183a5651ecb"

PR = "${INC_PR}.0"

require u-boot-altera.inc

