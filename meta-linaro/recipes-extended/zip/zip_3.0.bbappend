INSANE_SKIP_zip += "ldflags"
