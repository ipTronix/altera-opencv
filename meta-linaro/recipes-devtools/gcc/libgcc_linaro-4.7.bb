require gcc-linaro-common-4.7.inc
require recipes-devtools/gcc/libgcc_${BASEPV}.bb
