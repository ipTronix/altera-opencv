require gcc-linaro-common-4.7.inc
require recipes-devtools/gcc/gcc-cross-canadian_${BASEPV}.bb
