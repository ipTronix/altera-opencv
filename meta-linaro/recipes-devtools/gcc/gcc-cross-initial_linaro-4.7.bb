require gcc-linaro-common-4.7.inc
require recipes-devtools/gcc/gcc-cross-initial_${BASEPV}.bb
