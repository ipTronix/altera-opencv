require gcc-linaro-common-4.7.inc
require recipes-devtools/gcc/gcc-runtime_${BASEPV}.bb
