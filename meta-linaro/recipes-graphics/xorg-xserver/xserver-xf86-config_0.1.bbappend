# allows bitbake to find the xorg.conf for the qemuarmv7a MACHINE
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
