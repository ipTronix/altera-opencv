DTB_SUBDIR="dts/"
require recipes-kernel/linux/linux-altera-next.inc

