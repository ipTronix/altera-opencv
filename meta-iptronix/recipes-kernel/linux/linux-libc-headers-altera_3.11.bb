require linux-libc-headers-altera-next.inc
