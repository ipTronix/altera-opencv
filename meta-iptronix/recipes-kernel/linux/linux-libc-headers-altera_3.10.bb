require linux-libc-headers-altera.inc
